# Keil uVision project TiltV20.uvprojx, settings and files
target TiltV20 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L071RBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: TiltV20 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L071xx,USE_HAL_DRIVER,STM32L071xx
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;..\Src\i2c;..\Src\uart;..\Src\adc;..\Src\eeprom;..\Src\spi;..\Src\sx1278;..\Src\rtc;..\Src\crc;..\Src\MUP6050;..\Src\ADXL355;..\Src\pwr_mode_rtc;..\Src;..\Src;..\Src\EX_EEPROM;..\Src\4G_G8100;..\Drivers;..\Drivers\STM32L0xx_HAL_Driver\Inc;..\Src\Flash;..\Src\DMA
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32l071xx.s
  group Application/User
    ../Src/: Tilt_TSK.c LoRa_TSK.c main.c stm32l0xx_it.c stm32l0xx_hal_msp.c SysManage_TSK.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_iwdg.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group i2c
    ../Src/i2c/: bsp_i2c.c
  group uart
    ../Src/uart/: uart.c
  group adc
    ../Src/adc/: adc.c
  group eeprom
    ../Src/eeprom/: eeprom.c
  group spi
    ../Src/spi/: spi.c
  group sx1278
    ../Src/sx1278/: sx1278.c
  group rtc
    ../Src/rtc/: rtc.c
  group crc
    ../Src/crc/: crc.c
  group mpu6050
    ../Src/MUP6050/: mpu6050.c
  group ADXL355
    ../Src/ADXL355/: ADXL355.c InclinationCalc.c
  group PowerMode
    ../Src/pwr_mode_rtc/: pwr_mode_rtc.c
  group EX_EEPROM
    ../Src/EX_EEPROM/: EX_Eeprom_App.c EX_Eeprom_Driver.c
  group G8100_4G
    ../Src/4G_G8100/: 4g.c 4G_AT.c
  group Flash
    ../Src/Flash/: flash.c
  group DMA
    ../Src/DMA/: dma.c
  group ellipsoid
    ../Src/ellipsoid/: ellipsoid.c
software components: CMSIS:CORE 5.1.1
